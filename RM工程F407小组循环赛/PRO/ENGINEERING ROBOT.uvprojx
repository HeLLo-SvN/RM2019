# Keil uVision project ENGINEERING ROBOT.uvprojx, settings and files
target TOE (ARM-ADS)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ENGINEERING ROBOT
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\LIB;..\SYS;..\USER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../USER/: stm32f4xx_it.c startup_stm32f4xx.s
  group LIB
    ../LIB/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c system_stm32f4xx.c
  group BSP
    ../SYS/: delay.c delay.h usart6.c usart6.h usart1.c usart1.h can1.c can1.h tim7.c tim7.h can2.c can2.h tim6.c tim6.h usart2.c usart2.h
  group PID
    ../SYS/: pid.c pid.h chassispid.c chassispid.h liftpid.c liftpid.h grabpid.c grabpid.h rotatepid.c rotatepid.h gyropid.c gyropid.h feedback.c feedback.h action.c action.h
  group LOGIC
    ../SYS/: main.c main.h led.c led.h STMGood.c STMGood.h wheel.c wheel.h rc_init.c rc_init.h touch_switch.c touch_switch.h air_cylinder.c air_cylinder.h keyence.c keyence.h end_of.c end_of.h keyboard_value.c keyboard_value.h screen.c screen.h testing.c testing.h print.c print.h servo.c servo.h rescue.c rescue.h to_hero.c to_hero.h grab_check.c grab_check.h position_init.c position_init.h quit_mode.c quit_mode.h get_mode1.c get_mode1.h get_mode2.c get_mode2.h straight_angle.c straight_angle.h get_mode3.c get_mode3.h self_checking.c self_checking.h
